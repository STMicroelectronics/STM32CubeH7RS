<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\Template_OEMiROT_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
