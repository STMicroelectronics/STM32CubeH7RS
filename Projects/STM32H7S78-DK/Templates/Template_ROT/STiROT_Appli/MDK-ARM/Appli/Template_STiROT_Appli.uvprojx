# Keil uVision project Template_STiROT_Appli.uvprojx, settings and files
target Template_STiROT_Appli (6190000::V6.19::ARMCLANG)
  device: STM32H7S7L8Hx STMicroelectronics
  pack: Keil.STM32H7Rx-7Sx_DFP.0.1.0
  cpu: IROM(0x70000000-0x7FFFFFFF) IRAM(0x90000000-0x91FFFFFF) IROM2(0x00000000-0xFFFF) IRAM2(0x30000000-0x30007FFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Template_STiROT_Appli
  AfterMake: fromelf "#L" --bin --output="$L\..\..\..\..\Appli\Binary\appli.bin"
  AfterMake: postbuild.bat
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7S7xx
  c include: ../../Appli/Inc;../../../../../../../Drivers/BSP/STM32H7S78-DK;../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include;../../../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x24000000 size 0x72000
  memory RVCT5: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x30004000 size 0x4000
  scatter file: .\stm32h7sxx_app.sct
  link misc: --diag_suppress=L6312,L6314
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../Appli/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_tim.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_dma_ex.c
  group Example/MDK-ARM
    ../: startup_stm32h7s7xx.s
  group Example/User
    ../../Appli/Src/: main.c stm32h7rsxx_it.c
    ../../Appli/src/: stm32h7rsxx_hal_msp.c
  group Drivers/BSP/STM32H7S78-DK
    ../../../../../../../Drivers/BSP/STM32H7S78-DK/: stm32h7s78_discovery.c
software components: CMSIS:CORE 5.6.0
