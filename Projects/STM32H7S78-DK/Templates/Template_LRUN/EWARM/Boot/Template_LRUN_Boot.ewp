# IAR project Template_LRUN_Boot.ewp, settings and files
configuration Template_LRUN_Boot (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S7L8 ST STM32H7S7L8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7S7xx
  ICCARM.CCIncludePath2: ../../Boot/Inc; ../../../../../../Drivers/BSP/STM32H7S78-DK; ../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/boot; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/psram; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sdcard; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/user
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template_LRUN_Boot.hex
  ILINK.IlinkOutputFile: Template_LRUN_Boot.out
  ILINK.IlinkIcfFile: stm32h7s7xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32h7s7xx.s
  group Application/User/Boot
    ../../Boot/Src/: extmem_manager.c main.c stm32h7rsxx_hal_msp.c stm32h7rsxx_it.c
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32H7S78-DK
    ../../../../../../Drivers/BSP/STM32H7S78-DK/: stm32h7s78_discovery.c
  group Drivers/CMSIS
    ../../Boot/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_sd.c stm32h7rsxx_hal_sd_ex.c stm32h7rsxx_hal_tim.c stm32h7rsxx_hal_tim_ex.c stm32h7rsxx_hal_xspi.c stm32h7rsxx_ll_dlyb.c stm32h7rsxx_ll_sdmmc.c
  group Middlewares/STM32_ExtMem_Manager
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/boot/: stm32_boot_lrun.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/psram/: stm32_psram_driver.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal/: stm32_sal_sd.c stm32_sal_xspi.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sdcard/: stm32_sdcard_driver.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/user/: stm32_user_driver.c
