<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Boot\Template_LRUN_Boot.ewp</path>
  </project><project>
    <path>$WS_DIR$\Appli\Template_LRUN_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
