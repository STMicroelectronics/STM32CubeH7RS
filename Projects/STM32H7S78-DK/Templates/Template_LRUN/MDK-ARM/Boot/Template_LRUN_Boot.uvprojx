# Keil uVision project Template_LRUN_Boot.uvprojx, settings and files
target Template_LRUN_Boot (6190000::V6.19::ARMCLANG)
  device: STM32H7S7L8HxH STMicroelectronics
  pack: Keil.STM32H7Rx-7Sx_DFP.0.1.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Template_LRUN_Boot +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7S7xx
  c include: ../../Boot/Inc;../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc;../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/ST/STM32_ExtMem_Manager;../../../../../../Middlewares/ST/STM32_ExtMem_Manager/boot;../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal;../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp;../../../../../../Middlewares/ST/STM32_ExtMem_Manager/psram;../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sdcard;../../../../../../Middlewares/ST/STM32_ExtMem_Manager/user;../../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32H7S78-DK
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32h7s7xx_flash.sct
  link misc: --diag_suppress L6312,L6314
  group Application/MDK-ARM
    ../: startup_stm32h7s7xx.s
  group Application/User/Boot
    ../../Boot/Src/: main.c extmem_manager.c stm32h7rsxx_it.c stm32h7rsxx_hal_msp.c
  group Doc
    ../../: README.md
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_tim.c stm32h7rsxx_hal_tim_ex.c stm32h7rsxx_hal_xspi.c
  group Drivers/CMSIS
    ../../Boot/Src/: system_stm32h7rsxx.c
  group Drivers/BSP/STM32H7S78-DK
    ../../../../../../Drivers/BSP/STM32H7S78-DK/: stm32h7s78_discovery.c
  group Middlewares/STM32_ExtMem_Manager
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/boot/: stm32_boot_lrun.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal/: stm32_sal_xspi.c stm32_sal_sd.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/psram/: stm32_psram_driver.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sdcard/: stm32_sdcard_driver.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/user/: stm32_user_driver.c
software components: CMSIS:CORE 5.6.0
