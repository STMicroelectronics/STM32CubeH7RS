<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Boot\Template_XIP_Boot.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Appli\Template_XIP_Appli.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\ExtMemLoader\Template_XIP_ExtMemLoader.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>tes</name>
            <member>
                <project>Template_XIP_Appli</project>
                <configuration>Template_XIP_Appli</configuration>
            </member>
            <member>
                <project>Template_XIP_Boot</project>
                <configuration>Template_XIP_Boot</configuration>
            </member>
            <member>
                <project>Template_XIP_ExtMemLoader</project>
                <configuration>Template_XIP_ExtMemLoader</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
