# Keil uVision project Template_XIP_Custom_Appli.uvprojx, settings and files
target Template_XIP_Custom_Appli (6210000::V6.21::ARMCLANG)
  device: STM32H7S7L8HxH STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Template_XIP_Custom_Appli +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7S7xx
  c include: ../../Appli/Inc;../../../../../../Drivers/BSP/STM32H7S78-DK;../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include;../../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\stm32h7rsxx_RAMxspi1_ROMxspi2.sct
  link misc: --diag_suppress=L6312,L6314
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32H7S78-DK
    ../../../../../../Drivers/BSP/STM32H7S78-DK/: stm32h7s78_discovery.c
  group Drivers/CMSIS
    ../../Appli/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c
  group Example/MDK-ARM
    ../: startup_stm32h7s7xx.s
  group Example/User
    ../../Appli/Src/: main.c stm32h7rsxx_hal_msp.c stm32h7rsxx_it.c
software components: CMSIS:CORE 5.6.0
