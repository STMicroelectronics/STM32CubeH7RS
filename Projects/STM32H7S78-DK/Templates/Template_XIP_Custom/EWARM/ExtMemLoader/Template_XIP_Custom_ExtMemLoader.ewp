# IAR project Template_XIP_Custom_ExtMemLoader.ewp, settings and files
configuration Template_XIP_Custom_ExtMemLoader (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S7L8 ST STM32H7S7L8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H7S7xx; DEBUG_UART_NA; STM32_EXTMEMLOADER_EWARMTARGET_NA; STM32_EXTMEMLOADER_STM32CUBETARGET; STM32_EXTMEMLOADER_STM32CUBEOPENBLTARGET_NA; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\..\ExtMemLoader\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7RSxx\Include; ..\..\..\..\..\..\Drivers\STM32H7RSxx_HAL_Driver\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Manager; ..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Loader; ..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Loader\core; ..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Loader\EWARM; ..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Loader\STM32Cube; ../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/psram; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sdcard; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/user; ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/custom; ../../../../../../Middlewares/ST/STM32_ExtMem_Loader/MDK-ARM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32_EXTMEMLOADER_STM32CUBETARGET
  OBJCOPY.OOCOutputFile: Template_XIP_Custom_ExtMemLoader.bin
  postbuild: "postbuild.sh"
  ILINK.IlinkOutputFile: Template_XIP_Custom_ExtMemLoader.out
  ILINK.IlinkIcfFile: stm32h7rsxx_extmemloader_stm32cube.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User/ExtMemLoader
    ../../ExtMemLoader/Src/: extmem_manager.c extmemloader_init.c stm32h7rsxx_hal_msp.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../ExtMemLoader/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_xspi.c
  group Middlewares/STM32_ExtMem_Loader
    ../../../../../../Middlewares/ST/STM32_ExtMem_Loader/EWARM/: flash_loader.c flash_loader_asm.s stm32_flash_wrapper.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Loader/MDK-ARM/: FlashDev.c FlashPrg.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Loader/core/: memory_wrapper.c systick_management.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Loader/STM32Cube/: stm32_device_info.c stm32_loader_api.c
  group Middlewares/STM32_ExtMem_Manager
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/psram/: stm32_psram_driver.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal/: stm32_sal_sd.c stm32_sal_xspi.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sdcard/: stm32_sdcard_driver.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/user/: stm32_user_driver.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/custom/: stm32_custom_driver.c
