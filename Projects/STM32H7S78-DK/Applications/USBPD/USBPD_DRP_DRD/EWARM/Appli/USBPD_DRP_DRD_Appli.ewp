# IAR project USBPD_DRP_DRD_Appli.ewp, settings and files
configuration USBPD_DRP_DRD_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S78-DK ST STM32H7S78-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7S7xx; USE_FULL_LL_DRIVER; USBPD_PORT_COUNT=1; _RTOS; _DRP; _TRACE; USBPDCORE_LIB_PD3_FULL; TCPP0203_SUPPORT; USE_USB_HS; _GUI_INTERFACE
  ICCARM.CCIncludePath2: ../../Appli/Inc; ..\..\USB_Device; ..\..\USB_Host\App; ..\..\USB_Host\Target; ..\..\USB_Device\Appli\Inc; ../../../../../../../Drivers/BSP/STM32H7S78-DK; ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc; ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; ../../../../../../../Utilities/TRACER_EMB; ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../../../../../../Drivers/CMSIS/RTOS2/Include; ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/inc; ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32H7RSXX/inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; ../../../../../../../Drivers/CMSIS/Include; ../../../../../../../Drivers/BSP/Components/tcpp0203; ../../../../../../../Utilities/GUI_INTERFACE; ..\..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\HID\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\HID\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../../Appli/Inc
  OBJCOPY.OOCOutputFile: USBPD_DRP_DRD_Appli.hex
  ILINK.IlinkOutputFile: USBPD_DRP_DRD_Appli.out
  ILINK.IlinkIcfFile: stm32h7rsxx_RAMxspi1_ROMxspi2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32h7s7xx.s
  group Application/User/Appli
    ../../Appli/Src/: freertos.c main.c stm32h7rsxx_hal_msp.c stm32h7rsxx_hal_timebase_tim.c stm32h7rsxx_it.c
  group Application/User/Appli/USB/DEVICE
    ../../Appli/Src/: usb_device.c usbd_conf.c usbd_desc.c
  group Application/User/Appli/USB/HOST
    ../../Appli/Src/: usb_host.c usbh_conf.c usbh_platform.c
  group Application/User/Appli/USBPD/APP
    ../../Appli/Src/: usbpd.c usbpd_dpm_core.c usbpd_pwr_if.c usbpd_usb_if.c
  group Application/User/Appli/USBPD/Target
    ../../Appli/Src/: usbpd_dpm_user.c usbpd_pwr_user.c usbpd_vdm_user.c
  group Doc
    ../../: README.md
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/tcpp0203/: tcpp0203.c tcpp0203_reg.c
  group Drivers/BSP/STM32H7S78-DK
    ../../../../../../../Drivers/BSP/STM32H7S78-DK/: stm32h7s78_discovery.c stm32h7s78_discovery_bus.c stm32h7s78_discovery_usbpd_pwr.c
  group Drivers/CMSIS
    ../../Appli/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_adc.c stm32h7rsxx_hal_adc_ex.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_crc.c stm32h7rsxx_hal_crc_ex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma2d.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_gpu2d.c stm32h7rsxx_hal_hcd.c stm32h7rsxx_hal_i2c.c stm32h7rsxx_hal_i2c_ex.c stm32h7rsxx_hal_icache.c stm32h7rsxx_hal_jpeg.c stm32h7rsxx_hal_ltdc.c stm32h7rsxx_hal_pcd.c stm32h7rsxx_hal_pcd_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_smbus.c stm32h7rsxx_hal_smbus_ex.c stm32h7rsxx_hal_tim.c stm32h7rsxx_hal_tim_ex.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_ll_dma.c stm32h7rsxx_ll_exti.c stm32h7rsxx_ll_gpio.c stm32h7rsxx_ll_lpuart.c stm32h7rsxx_ll_rcc.c stm32h7rsxx_ll_tim.c stm32h7rsxx_ll_ucpd.c stm32h7rsxx_ll_usart.c stm32h7rsxx_ll_usb.c stm32h7rsxx_ll_utils.c
  group Middlewares/FreeRTOS
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/STM32_USBPD_Library
    ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32H7RSXX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c usbpd_timersserver.c
    ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_trace.c
    ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_PD3_FULL_CM7_wc32.a
  group Middlewares/USB_DEVICE/Class
    ../../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Middlewares/USB_DEVICE/Core
    ../../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/USB_HOST/Class
    ../../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c
  group Middlewares/USB_HOST/Core
    ../../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Utilities
    ../../../../../../../Utilities/GUI_INTERFACE/: bsp_gui.c data_struct_tlv.c gui_api.c
    ../../../../../../../Utilities/TRACER_EMB/: tracer_emb.c tracer_emb_hw.c
