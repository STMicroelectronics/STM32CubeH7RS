# IAR project Audio_Standalone_Appli.ewp, settings and files
configuration Audio_Standalone_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S7L8 ST STM32H7S7L8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7S7xx
  ICCARM.CCIncludePath2: ../../Appli/Inc; ../../../../../../../Drivers/BSP/STM32H7S78-DK; ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc; ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; ../../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; ../../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Audio_Standalone_Appli.hex
  ILINK.IlinkOutputFile: Audio_Standalone_Appli.out
  ILINK.IlinkIcfFile: stm32h7rsxx_RAMxspi1_ROMxspi2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32h7s7xx.s
  group Application/User/Appli
    ../../Appli/Src/: main.c stm32h7rsxx_hal_msp.c stm32h7rsxx_it.c usb_device.c usbd_audio_if.c usbd_conf.c usbd_desc.c
  group Doc
    ../../: README.md
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/wm8904/: wm8904.c wm8904_reg.c
  group Drivers/BSP/STM32H7S78-DK
    ../../../../../../../Drivers/BSP/STM32H7S78-DK/: stm32h7s78_discovery.c stm32h7s78_discovery_audio.c stm32h7s78_discovery_bus.c
  group Drivers/CMSIS
    ../../Appli/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_i2c.c stm32h7rsxx_hal_i2c_ex.c stm32h7rsxx_hal_i2s.c stm32h7rsxx_hal_i2s_ex.c stm32h7rsxx_hal_mdf.c stm32h7rsxx_hal_pcd.c stm32h7rsxx_hal_pcd_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_smbus.c stm32h7rsxx_hal_smbus_ex.c stm32h7rsxx_ll_usb.c
  group Middlewares/STM32_USB_Device_Library
    ../../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Src/: usbd_audio.c
    ../../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
