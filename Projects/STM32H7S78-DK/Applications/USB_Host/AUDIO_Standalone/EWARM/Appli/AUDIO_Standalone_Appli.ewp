# IAR project AUDIO_Standalone_Appli.ewp, settings and files
configuration AUDIO_Standalone_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S78-DK ST STM32H7S78-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7S7xx
  ICCARM.CCIncludePath2: ../../Appli/Inc; ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc; ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; ../../../../../../../Middlewares/Third_Party/FatFs/source; ../../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc; ../../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/AUDIO/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; ../../../../../../../Drivers/CMSIS/Include; ../../../../../../../Middlewares\Third_Party\FatFs\source\drivers\sd
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AUDIO_Standalone_Appli.hex
  ILINK.IlinkOutputFile: AUDIO_Standalone_Appli.out
  ILINK.IlinkIcfFile: stm32h7rsxx_RAMxspi1_ROMxspi2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32h7s7xx.s
  group Application/User/Appli
    ../../Appli/Src/: audio.c explorer.c fatfs.c main.c stm32h7rsxx_hal_msp.c stm32h7rsxx_it.c usb_host.c usbh_conf.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../Appli/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_hcd.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_sd.c stm32h7rsxx_hal_sd_ex.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_ll_dlyb.c stm32h7rsxx_ll_sdmmc.c stm32h7rsxx_ll_usb.c
  group Middlewares/FatFs
    ../../../../../../../Middlewares/Third_Party/FatFs/source/: diskio.c ff.c ff_gen_drv.c ffunicode.c
    ../../../../../../../Middlewares/Third_Party/FatFs/source/drivers/sd/: sd_diskio_dma_standalone.c
  group Middlewares/STM32_USB_Host_Library
    ../../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/AUDIO/Src/: usbh_audio.c
    ../../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
