# Keil uVision project MSC_RTOS_Appli.uvprojx, settings and files
target MSC_RTOS_Appli (6190000::V6.19::ARMCLANG)
  device: STM32H7S7L8HxH STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x24000000-0x24071BFF) IROM(0x8000000-0x800FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: MSC_RTOS_Appli +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7S7xx,USE_FULL_LL_DRIVER,USBPD_PORT_COUNT=1,_RTOS,_SRC,USBPDCORE_LIB_NO_PD,TCPP0203_SUPPORT
  c include: ../../Appli/Inc;../../../../../../../Drivers/BSP/STM32H7S78-DK;./../../../../../Drivers/BSP/Components/tcpp0203;../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc;../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../../../../../../../Drivers/CMSIS/RTOS2/Include;../../../../../../../Middlewares/Third_Party/FatFs/source;../../../../../../../Middlewares/Third_Party/FatFs/source/drivers/template;../../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/inc;../../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32H7RSXX/inc;../../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include;../../../../../../../Drivers/CMSIS/Include;..\..\..\..\..\..\..\Middlewares\Third_Party\FatFs\source\drivers\usb_host
  asm include: ../Appli/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x24000000 size 0x71c00
  scatter file: .\MSC_RTOS_Appli.sct
  link misc: --diag_suppress L6312,L6314
  group Application/MDK-ARM
    ../: startup_stm32h7s7xx.s
  group Application/User/Appli
    ../../Appli/Src/: main.c freertos.c user_diskio.c fatfs.c usbpd.c usbpd_dpm_user.c usbpd_dpm_core.c usbpd_pwr_user.c usbpd_pwr_if.c usbpd_usb_if.c usb_host.c usbh_conf.c stm32h7rsxx_it.c stm32h7rsxx_hal_msp.c stm32h7rsxx_hal_timebase_tim.c explorer.c file_operations.c
  group Doc
    ../../: README.md
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_exti.c stm32h7rsxx_ll_rcc.c stm32h7rsxx_ll_exti.c stm32h7rsxx_hal_i2c.c stm32h7rsxx_hal_i2c_ex.c stm32h7rsxx_hal_smbus.c stm32h7rsxx_hal_smbus_ex.c stm32h7rsxx_hal_tim.c stm32h7rsxx_hal_tim_ex.c stm32h7rsxx_hal_hcd.c stm32h7rsxx_ll_usb.c stm32h7rsxx_ll_utils.c stm32h7rsxx_hal_adc.c stm32h7rsxx_hal_adc_ex.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_ll_ucpd.c stm32h7rsxx_ll_gpio.c stm32h7rsxx_ll_dma.c stm32h7rsxx_ll_tim.c
  group Drivers/CMSIS
    ../../Appli/Src/: system_stm32h7rsxx.c
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/tcpp0203/: tcpp0203.c tcpp0203_reg.c
  group Drivers/BSP/STM32H7S78-DK
    ../../../../../../../Drivers/BSP/STM32H7S78-DK/: stm32h7s78_discovery.c stm32h7s78_discovery_bus.c stm32h7s78_discovery_usbpd_pwr.c
  group Middlewares/FreeRTOS
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Middlewares/STM32_USB_Host_Library
    ../../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/STM32_USBPD_Library
    ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_trace.c
    ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32H7RSXX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c
    ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_NOPD_CM7_Keil.lib
  group Middlewares/FatFs
    ../../../../../../../Middlewares/Third_Party/FatFs/source/: diskio.c ffsystem_template.c ff.c ff_gen_drv.c ffsystem_cmsis_os.c ffunicode.c
    ../../../../../../../Middlewares/Third_Party/FatFs/source/drivers/usb_host/: usbh_diskio.c
software components: CMSIS:CORE 5.6.0
