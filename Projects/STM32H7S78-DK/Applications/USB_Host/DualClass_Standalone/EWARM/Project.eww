<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Boot\DualClass_Standalone_Boot.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Appli\DualClass_Standalone_Appli.ewp</path>
    </project>
    <batchBuild />
</workspace>
