# IAR project Project.ewp, settings and files
configuration STM32H7S78-DK_STiROT_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S78-DK ST STM32H7S78-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H7S7xx; USE_HAL_DRIVER; USE_STM32H7S78_DK; BL2_HW_ACCEL_ENABLE; STM32; STM32H7S7L8HxH
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7RSxx\Include; ..\..\..\..\..\..\Drivers\STM32H7RSxx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32H7S78-DK
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\..\Binary\appli.bin
  postbuild: "postbuild.bat"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32h7s7xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../Src/: com.c main.c stm32h7rsxx_it.c test_versions.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ./: startup_stm32h7s7xx.s
    ../Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_rng.c stm32h7rsxx_hal_rng_ex.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c
