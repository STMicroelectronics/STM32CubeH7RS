# Keil uVision project Project.uvprojx, settings and files
target STM32H7S78-DK_STiROT_Appli (6190000::V6.19::ARMCLANG)
  device: STM32H7S7L8Hx STMicroelectronics
  pack: Keil.STM32H7Rx-7Sx_DFP.0.1.0
  cpu: IROM(0x70000000-0x7FFFFFFF) IRAM(0x90000000-0x91FFFFFF) IROM2(0x00000000-0xFFFF) IRAM2(0x30000000-0x30007FFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H7S78-DK_STiROT_Appli
  AfterMake: fromelf "#L" --bin --output="$L\..\..\..\Binary\appli.bin"
  AfterMake: postbuild.bat
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32,USE_HAL_DRIVER,STM32H7S7xx,BL2_HW_ACCEL_ENABLE,USE_STM32H7S78_DK,STM32H7S7L8HxH
  c include: ../Inc;../../../../../../Drivers/BSP/STM32H7S78-DK;../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include;../../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x24000000 size 0x72000
  memory RVCT5: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x30004000 size 0x4000
  scatter file: .\stm32h7sxx_app.sct
  link misc: --diag_suppress=L6312,L6314
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_rng.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_rng_ex.c
  group Example/MDK-ARM
    ./: startup_stm32h7s7xx.s
  group Example/User
    ../Src/: main.c com.c stm32h7rsxx_it.c test_versions.c
software components: CMSIS:CORE 5.6.0
