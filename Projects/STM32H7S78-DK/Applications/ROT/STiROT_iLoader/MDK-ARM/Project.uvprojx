# Keil uVision project Project.uvprojx, settings and files
target STM32H7S78-DK_STiROT_iLoader (6190000::V6.19::ARMCLANG)
  device: STM32H7S7L8Hx STMicroelectronics
  pack: Keil.STM32H7Rx-7Sx_DFP.0.1.1
  cpu: IROM(0x70000000-0x7FFFFFFF) IRAM(0x90000000-0x91FFFFFF) IROM2(0x00000000-0xFFFF) IRAM2(0x30000000-0x30007FFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H7S78-DK_STiROT_iLoader
  BeforeMake: prebuild.bat
  AfterMake: fromelf "#L" --bin --output="$L\..\..\..\Binary\STiROT_iLoader.bin"
  AfterMake: postbuild.bat
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32,USE_HAL_DRIVER,STM32H7S7xx,ILOADER_USE_CACHE,USE_STM32H7S78_DK,STM32H7S7L8HxH
  c include: ../Inc;../../../../../../Drivers/BSP/STM32H7S78-DK;../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp;../../../../../../Middlewares/ST/STM32_ExtMem_Manager
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x0 size 0x10000
  memory RVCT6: RAM 0x2000ffc0 size 0x40
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x30004000 size 0x4000
  scatter file: .\stm32h7sxx_iloader.sct
  link misc: --diag_suppress=L6312,L6314
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_xspi.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c
  group Example/MDK-ARM
    ./: startup_stm32h7s7xx.s
  group Example/User
    ../Src/: main.c com.c stm32h7rsxx_it.c loader.c low_level_flash_ext.c low_level_shared_mem.c stm32h7rsxx_hal_msp.c
  group Middlewares/STM32_ExtMem_Manager/PSRAM
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/psram/: stm32_psram_driver.c
  group Middlewares/STM32_ExtMem_Manager/SAL
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal/: stm32_sal_xspi.c
  group Middlewares/STM32_ExtMem_Manager/SFDP
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
  group Middlewares/STM32_ExtMem_Manager
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
software components: CMSIS:CORE 5.6.0
