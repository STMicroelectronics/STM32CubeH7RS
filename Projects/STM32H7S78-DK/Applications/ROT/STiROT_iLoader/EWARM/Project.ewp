# IAR project Project.ewp, settings and files
configuration STM32H7S78-DK_STiROT_iLoader (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S78-DK ST STM32H7S78-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H7S7xx; USE_HAL_DRIVER; ILOADER_USE_CACHE; STM32; USE_STM32H7S78_DK; STM32H7S7L8HxH
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7RSxx\Include; ..\..\..\..\..\..\Drivers\STM32H7RSxx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32H7S78-DK; ..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Manager; ..\..\..\..\..\..\Middlewares\ST\STM32_ExtMem_Manager\nor_sfdp
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  prebuild: "prebuild.cmd" "$PROJ_DIR$"
  postbuild: "postbuild.cmd" "$PROJ_DIR$"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32h7s7xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_xspi.c
  group Middlewares/STM32_ExtMem_Manager
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
  group Middlewares/STM32_ExtMem_Manager/PSRAM
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/psram/: stm32_psram_driver.c
  group Middlewares/STM32_ExtMem_Manager/SAL
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/sal/: stm32_sal_xspi.c
  group Middlewares/STM32_ExtMem_Manager/SFDP
    ../../../../../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
  group Example/EWARM
    ./: startup_stm32h7s7xx.s
  group Example/User
    ../Src/: com.c loader.c low_level_flash_ext.c low_level_shared_mem.c main.c stm32h7rsxx_hal_msp.c stm32h7rsxx_it.c
