# IAR project LwIP_TFTP_Server_Appli.ewp, settings and files
configuration LwIP_TFTP_Server_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S78-DK ST STM32H7S78-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7S7xx
  ICCARM.CCIncludePath2: ../../Appli/Inc; ../../../../../../../Middlewares/Third_Party/LwIP/src/include; ../../../../../../../Middlewares/Third_Party/LwIP/system; ../../../../../../../Middlewares/Third_Party/LwIP/src/include; ../../../../../../../Middlewares/Third_Party/LwIP/system; ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc; ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; ../../../../../../../Middlewares/Third_Party/FatFs/source; ../../../../../../../Middlewares/Third_Party/FatFs/source/drivers/sd; ../../../../../../../Drivers/BSP/Components/lan8742; ../../../../../../../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../../../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; ../../../../../../../Middlewares/Third_Party/LwIP/src/include/lwip; ../../../../../../../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../../../../../../../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../../../../../../../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../../../../../../../Middlewares/Third_Party/LwIP/src/include/netif; ../../../../../../../Middlewares/Third_Party/LwIP/src/include/compat/posix; ../../../../../../../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa; ../../../../../../../Middlewares/Third_Party/LwIP/src/include/compat/posix/net; ../../../../../../../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys; ../../../../../../../Middlewares/Third_Party/LwIP/src/include/compat/stdc; ../../../../../../../Middlewares/Third_Party/LwIP/system/arch; ../../../../../../../Drivers/CMSIS/Include; ../../../../../../../Drivers/BSP/STM32H7S78-DK
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LwIP_TFTP_Server_Appli.hex
  ILINK.IlinkOutputFile: LwIP_TFTP_Server_Appli.out
  ILINK.IlinkIcfFile: stm32h7rsxx_RAMxspi1_ROMxspi2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32h7s7xx.s
  group Application/User/Appli
    ../../Appli/Src/: ethernetif.c fatfs.c lwip.c main.c stm32h7rsxx_hal_msp.c stm32h7rsxx_it.c
  group Doc
    ../../: README.md
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/lan8742/: lan8742.c
  group Drivers/CMSIS
    ../../Appli/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_eth.c stm32h7rsxx_hal_eth_ex.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_sd.c stm32h7rsxx_hal_sd_ex.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_ll_dlyb.c stm32h7rsxx_ll_sdmmc.c
  group Middlewares/FatFs
    ../../../../../../../Middlewares/Third_Party/FatFs/source/: diskio.c ff.c ff_gen_drv.c ffsystem_template.c ffunicode.c
    ../../../../../../../Middlewares/Third_Party/FatFs/source/drivers/sd/: sd_diskio.c
  group Middlewares/LwIP
    ../../../../../../../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../../../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../../../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
