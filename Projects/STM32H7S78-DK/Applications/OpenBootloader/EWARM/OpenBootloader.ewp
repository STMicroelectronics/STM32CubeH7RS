# IAR project OpenBootloader.ewp, settings and files
configuration STM32H7S78-DK_Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7R7L8 ST STM32H7R7L8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H7S7xx; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; CORE_CM7; USE_USB_FS; VECT_FLASH
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\OpenBootloader\App; ..\OpenBootloader\Target; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Core; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\STM32H7RSxx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7RSxx\Include; ..\USB_Device\App; ..\USB_Device\Target; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\DFU\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Core; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Modules\SPI; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Modules\FDCAN; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Modules\I2C; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Modules\I3C; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Modules\Mem; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Modules\USART; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Modules\USB
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: TX_SINGLE_MODE_NON_SECURE=1
  OBJCOPY.OOCOutputFile: OpenBootloader_STM32H7RS-DK.bin
  ILINK.IlinkOutputFile: OpenBootloader.out
  ILINK.IlinkIcfFile: stm32h7rsxx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32H7S78-DK_Ram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32H7S7xx; USE_FULL_LL_DRIVER; USE_HAL_DRIVER; CORE_CM7; USE_USB_FS; VECT_RAM
  ILINK.IlinkIcfFile: stm32h7rsxx_ram.icf
  group Application/Core
    ../Core/Src/: main.c stm32h7rsxx_hal_msp.c stm32h7rsxx_it.c
  group Application/EWARM
    ./: startup_stm32h7s7xx.s
  group Application/Openbootloader/App
    ../OpenBootloader/App/: app_openbootloader.c
  group Application/Openbootloader/Target
    ../OpenBootloader/Target/: common_interface.c engibytes_interface.c external_memory_interface.c fdcan_interface.c flash_interface.c i2c_interface.c i3c_interface.c iwdg_interface.c optionbytes_interface.c otp_interface.c ram_interface.c readonly_interface.c spi_interface.c systemmemory_interface.c usart_interface.c usb_interface.c
  group Application/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_desc.c usbd_dfu_if.c
  group Application/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_adc.c stm32h7rsxx_hal_adc_ex.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_fdcan.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_hcd.c stm32h7rsxx_hal_i2c.c stm32h7rsxx_hal_i2c_ex.c stm32h7rsxx_hal_i3c.c stm32h7rsxx_hal_iwdg.c stm32h7rsxx_hal_pcd.c stm32h7rsxx_hal_pcd_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_spi.c stm32h7rsxx_hal_spi_ex.c stm32h7rsxx_hal_usart.c stm32h7rsxx_hal_usart_ex.c stm32h7rsxx_ll_gpio.c stm32h7rsxx_ll_i2c.c stm32h7rsxx_ll_i3c.c stm32h7rsxx_ll_rcc.c stm32h7rsxx_ll_spi.c stm32h7rsxx_ll_usart.c stm32h7rsxx_ll_usb.c
  group Middlewares/OpenBootloader/Core
    ../../../../../Middlewares/ST/OpenBootloader/Core/: openbl_core.c
  group Middlewares/OpenBootloader/Modules/FDCAN
    ../../../../../Middlewares/ST/OpenBootloader/Modules/FDCAN/: openbl_fdcan_cmd.c
  group Middlewares/OpenBootloader/Modules/I2C
    ../../../../../Middlewares/ST/OpenBootloader/Modules/I2C/: openbl_i2c_cmd.c
  group Middlewares/OpenBootloader/Modules/I3C
    ../../../../../Middlewares/ST/OpenBootloader/Modules/I3C/: openbl_i3c_cmd.c
  group Middlewares/OpenBootloader/Modules/MEM
    ../../../../../Middlewares/ST/OpenBootloader/Modules/Mem/: openbl_mem.c
  group Middlewares/OpenBootloader/Modules/SPI
    ../../../../../Middlewares/ST/OpenBootloader/Modules/SPI/: openbl_spi_cmd.c
  group Middlewares/OpenBootloader/Modules/USART
    ../../../../../Middlewares/ST/OpenBootloader/Modules/USART/: openbl_usart_cmd.c
  group Middlewares/OpenBootloader/Modules/USB
    ../../../../../Middlewares/ST/OpenBootloader/Modules/USB/: openbl_usb_cmd.c
  group Middlewares/USB_Device_Library
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
