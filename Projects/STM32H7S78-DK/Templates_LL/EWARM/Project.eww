<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
    <path>$WS_DIR$\Boot\Templates_LL_Boot.ewp</path>
    </project>
  <batchBuild />
</workspace>
