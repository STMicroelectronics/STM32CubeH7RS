# IAR project Templates_LL_Boot.ewp, settings and files
configuration Templates_LL_Boot (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S7L8 ST STM32H7S7L8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H7S7xx; USE_FULL_LL_DRIVER; HSE_VALUE=24000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; EXTERNAL_CLOCK_VALUE=12288000; HSI_VALUE=64000000; LSI_VALUE=32000; VDD_VALUE=3300
  ICCARM.CCIncludePath2: ../../Boot/Inc; ../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc; ../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; ../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Templates_LL_Boot.hex
  ILINK.IlinkOutputFile: Templates_LL_Boot.out
  ILINK.IlinkIcfFile: stm32h7s7xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32h7s7xx.s
  group Application/User/Boot
    ../../Boot/Src/: main.c stm32h7rsxx_it.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../Boot/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_ll_adc.c stm32h7rsxx_ll_cordic.c stm32h7rsxx_ll_crc.c stm32h7rsxx_ll_crs.c stm32h7rsxx_ll_dma.c stm32h7rsxx_ll_dma2d.c stm32h7rsxx_ll_i2c.c stm32h7rsxx_ll_i3c.c stm32h7rsxx_ll_lptim.c stm32h7rsxx_ll_lpuart.c stm32h7rsxx_ll_pka.c stm32h7rsxx_ll_rng.c stm32h7rsxx_ll_rtc.c stm32h7rsxx_ll_spi.c stm32h7rsxx_ll_tim.c stm32h7rsxx_ll_ucpd.c stm32h7rsxx_ll_usart.c stm32h7rsxx_ll_gpio.c stm32h7rsxx_ll_exti.c stm32h7rsxx_ll_rcc.c stm32h7rsxx_ll_utils.c stm32h7rsxx_ll_pwr.c
