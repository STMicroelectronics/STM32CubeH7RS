# Keil uVision project Project.uvprojx, settings and files
target STM32H7S78-DK_Templates_LL (6190000::V6.19::ARMCLANG)
  device: STM32H7S7L8Hx STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H7S78-DK_Template_LL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32H7S7xx,USE_FULL_LL_DRIVER
  c include: ../Inc;..\Boot\Inc;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include;../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\stm32h7s7xx_flash.sct
  link misc: --diag_suppress=L6312,L6314
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Boot/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_ll_adc.c stm32h7rsxx_ll_cordic.c stm32h7rsxx_ll_crc.c stm32h7rsxx_ll_crs.c stm32h7rsxx_ll_dma.c stm32h7rsxx_ll_exti.c stm32h7rsxx_ll_gpio.c stm32h7rsxx_ll_i2c.c stm32h7rsxx_ll_i3c.c stm32h7rsxx_ll_lptim.c stm32h7rsxx_ll_lpuart.c stm32h7rsxx_ll_pka.c stm32h7rsxx_ll_pwr.c stm32h7rsxx_ll_rcc.c stm32h7rsxx_ll_rng.c stm32h7rsxx_ll_rtc.c stm32h7rsxx_ll_spi.c stm32h7rsxx_ll_tim.c stm32h7rsxx_ll_ucpd.c stm32h7rsxx_ll_usart.c stm32h7rsxx_ll_utils.c
  group Example/MDK-ARM
    ./: startup_stm32h7s7xx.s
  group Example/User
    ../Boot/Src/: main.c stm32h7rsxx_it.c
software components: CMSIS:CORE 5.6.0
