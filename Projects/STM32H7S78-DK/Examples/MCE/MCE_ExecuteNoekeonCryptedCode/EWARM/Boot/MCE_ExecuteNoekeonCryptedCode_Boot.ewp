# IAR project MCE_ExecuteNoekeonCryptedCode_Boot.ewp, settings and files
configuration MCE_ExecuteNoekeonCryptedCode_Boot (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S78-DK ST STM32H7S78-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7S7xx
  ICCARM.CCIncludePath2: ../../Boot/Inc; ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc; ../../../../../../../Drivers/BSP/STM32H7S78-DK; ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; ../../../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; ../../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MCE_ExecuteNoekeonCryptedCode_Boot.hex
  ILINK.IlinkOutputFile: MCE_ExecuteNoekeonCryptedCode_Boot.out
  ILINK.IlinkIcfFile: stm32h7s7xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32h7s7xx.s
  group Application/User/Boot
    ../../Boot/Src/: main.c stm32h7rsxx_it.c stm32h7rsxx_hal_msp.c
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32H7S78-DK
    ../../../../../../../Drivers/BSP/STM32H7S78-DK/: stm32h7s78_discovery.c
  group Drivers/CMSIS
    ../../Boot/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_mce.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_tim.c stm32h7rsxx_hal_tim_ex.c stm32h7rsxx_hal_xspi.c
