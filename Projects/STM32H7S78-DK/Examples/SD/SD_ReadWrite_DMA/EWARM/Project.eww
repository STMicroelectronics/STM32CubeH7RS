<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\SD_ReadWrite_DMA_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
