<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\ADF_AudioSoundDetector_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
