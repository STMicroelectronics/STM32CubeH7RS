# IAR project Project.ewp, settings and files
configuration STM32H7S78-DK (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S7L8 ST STM32H7S7L8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H7S7xx; USE_HAL_DRIVER; USE_STM32H7S78_DK; __TERMINAL_IO__; USER_VECT_TAB_ADDRESS; VECT_TAB_SRAM
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7RSxx\Include; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\STM32H7RSxx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32H7S78-DK; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\Components\wm8904; ..\..\..\..\..\Utilities\lcd; ..\..\..\..\..\Utilities\lFonts; ..\..\..\..\..\Utilities\Log; ..\..\..\..\..\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32h7s7xx_sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/iar/: startup_stm32h7s7xx.s
  group Application/User
    ../Src/: audio_play.c audio_record.c lcd.c main.c sd.c stm32h7rsxx_hal_msp.c stm32h7rsxx_it.c touchscreen.c
  group Doc
    ../: README.md
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/aps256xx/: aps256xx.c
    ../../../../../Drivers/BSP/Components/gt911/: gt911.c gt911_reg.c
    ../../../../../Drivers/BSP/Components/mx66uw1g45g/: mx66uw1g45g.c
    ../../../../../Drivers/BSP/Components/wm8904/: wm8904.c wm8904_reg.c
  group Drivers/BSP/STM32H7S78-DK
    ../../../../../Drivers/BSP/STM32H7S78-DK/: stm32h7s78_discovery.c stm32h7s78_discovery_audio.c stm32h7s78_discovery_bus.c stm32h7s78_discovery_lcd.c stm32h7s78_discovery_sd.c stm32h7s78_discovery_ts.c stm32h7s78_discovery_xspi.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma2d.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_i2c.c stm32h7rsxx_hal_i2c_ex.c stm32h7rsxx_hal_i2s.c stm32h7rsxx_hal_i2s_ex.c stm32h7rsxx_hal_lptim.c stm32h7rsxx_hal_ltdc.c stm32h7rsxx_hal_mdf.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_sd.c stm32h7rsxx_hal_sd_ex.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_xspi.c stm32h7rsxx_ll_sdmmc.c
  group Utilities
    ../../../../../Utilities/lcd/: stm32_lcd.c
