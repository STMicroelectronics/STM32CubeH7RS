<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\JPEG_EncodingFromXSPI_DMA_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
