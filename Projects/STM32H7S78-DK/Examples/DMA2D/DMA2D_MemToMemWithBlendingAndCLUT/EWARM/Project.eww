<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\DMA2D_MemToMemWithBlendingAndCLUT_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
