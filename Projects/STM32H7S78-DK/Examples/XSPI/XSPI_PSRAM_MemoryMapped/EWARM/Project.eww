<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Boot\XSPI_PSRAM_MemoryMapped_Boot.ewp</path>
  </project>
  <batchBuild />
</workspace>
