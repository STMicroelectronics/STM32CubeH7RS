<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\FreeRTOS_Semaphore_LowPower_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
