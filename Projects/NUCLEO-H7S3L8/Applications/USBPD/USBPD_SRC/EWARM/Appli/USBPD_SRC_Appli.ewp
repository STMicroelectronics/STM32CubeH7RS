# IAR project USBPD_SRC_Appli.ewp, settings and files
configuration USBPD_SRC_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S38-NUCLEO ST STM32H7S38-NUCLEO
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7S3xx; USE_FULL_LL_DRIVER; USBPD_PORT_COUNT=1; _SRC; _TRACE; _RTOS; USBPDCORE_LIB_PD3_FULL; TCPP0203_SUPPORT; _GUI_INTERFACE
  ICCARM.CCIncludePath2: ../../Appli/Inc; ../../../../../../../Drivers/BSP/STM32H7RSxx_Nucleo; ../../../../../../../Drivers/BSP/Components/tcpp0203; ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc; ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; ../../../../../../../Utilities/GUI_INTERFACE; ../../../../../../../Utilities/TRACER_EMB; ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../../../../../../Drivers/CMSIS/RTOS2/Include; ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/inc; ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32H7RSXX/inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; ../../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../Appli/Inc
  OBJCOPY.OOCOutputFile: USBPD_SRC_Appli.hex
  ILINK.IlinkOutputFile: USBPD_SRC_Appli.out
  ILINK.IlinkIcfFile: stm32h7rsxx_ROMxspi2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32h7s3xx.s
  group Application/User/Appli
    ../../Appli/Src/: usbpd.c main.c freertos.c usbpd_dpm_user.c usbpd_dpm_core.c usbpd_vdm_user.c usbpd_pwr_user.c usbpd_pwr_if.c stm32h7rsxx_it.c stm32h7rsxx_hal_msp.c stm32h7rsxx_hal_timebase_tim.c
  group Doc
    ../../: README.md
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/tcpp0203/: tcpp0203.c tcpp0203_reg.c
  group Drivers/BSP/STM32H7RSxx_Nucleo
    ../../../../../../../Drivers/BSP/STM32H7RSxx_Nucleo/: stm32h7rsxx_nucleo.c stm32h7rsxx_nucleo_bus.c stm32h7rsxx_nucleo_usbpd_pwr.c
  group Drivers/CMSIS
    ../../Appli/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_tim.c stm32h7rsxx_hal_tim_ex.c stm32h7rsxx_hal_i2c.c stm32h7rsxx_hal_i2c_ex.c stm32h7rsxx_hal_smbus.c stm32h7rsxx_hal_smbus_ex.c stm32h7rsxx_hal_adc.c stm32h7rsxx_hal_adc_ex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_exti.c stm32h7rsxx_ll_rcc.c stm32h7rsxx_ll_utils.c stm32h7rsxx_ll_exti.c stm32h7rsxx_ll_usart.c stm32h7rsxx_ll_lpuart.c stm32h7rsxx_ll_ucpd.c stm32h7rsxx_ll_gpio.c stm32h7rsxx_ll_dma.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_ll_tim.c
  group Middlewares/FreeRTOS
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/STM32_USBPD_Library
    ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_PD3_FULL_CM7_wc32.a
    ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_trace.c
    ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32H7RSXX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c usbpd_timersserver.c
  group Utilities
    ../../../../../../../Utilities/GUI_INTERFACE/: bsp_gui.c gui_api.c data_struct_tlv.c
    ../../../../../../../Utilities/TRACER_EMB/: tracer_emb.c tracer_emb_hw.c
