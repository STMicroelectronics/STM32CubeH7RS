# IAR project CDC_HID_Standalone_Appli.ewp, settings and files
configuration CDC_HID_Standalone_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S38-NUCLEO ST STM32H7S38-NUCLEO
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7S3xx; TCPP0203_SUPPORT; USBD_COMPOSITE_USE_IAD; USE_USBD_COMPOSITE; USBPDCORE_LIB_NO_PD; USBPD_PORT_COUNT=1; USE_FULL_LL_DRIVER; _SNK; USE_USB_HS
  ICCARM.CCIncludePath2: ../../Appli/Inc; ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc; ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; ../../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; ../../../../../../../Drivers/CMSIS/Include; ../../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CompositeBuilder/Inc; ../../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc; ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/inc; ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32H7RSXX/inc; ../../../../../../../Drivers/BSP/STM32H7RSxx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CDC_HID_Standalone_Appli.hex
  ILINK.IlinkOutputFile: CDC_HID_Standalone_Appli.out
  ILINK.IlinkIcfFile: stm32h7rsxx_ROMxspi2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32h7s3xx.s
  group Application/User/Appli
    ../../Appli/Src/: main.c stm32h7rsxx_hal_msp.c stm32h7rsxx_it.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c usbpd.c usbpd_dpm_core.c usbpd_dpm_user.c usbpd_pwr_if.c usbpd_pwr_user.c usbpd_usb_if.c
  group Doc
    ../../: README.md
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/tcpp0203/: tcpp0203.c tcpp0203_reg.c
  group Drivers/BSP/STM32H7RSxx_Nucleo
    ../../../../../../../Drivers/BSP/STM32H7RSxx_Nucleo/: stm32h7rsxx_nucleo.c stm32h7rsxx_nucleo_bus.c stm32h7rsxx_nucleo_usbpd_pwr.c
  group Drivers/CMSIS
    ../../Appli/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_adc.c stm32h7rsxx_hal_adc_ex.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_i2c.c stm32h7rsxx_hal_i2c_ex.c stm32h7rsxx_hal_pcd.c stm32h7rsxx_hal_pcd_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_tim.c stm32h7rsxx_hal_tim_ex.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_ll_dma.c stm32h7rsxx_ll_exti.c stm32h7rsxx_ll_gpio.c stm32h7rsxx_ll_rcc.c stm32h7rsxx_ll_tim.c stm32h7rsxx_ll_ucpd.c stm32h7rsxx_ll_usb.c stm32h7rsxx_ll_utils.c
  group Middlewares/STM32_USB_Device_Library
    ../../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CompositeBuilder/Src/: usbd_composite_builder.c
    ../../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/HID/Src/: usbd_hid.c
  group Middlewares/STM32_USBPD_Library
    ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Devices/STM32H7RSXX/src/: usbpd_cad_hw_if.c usbpd_hw.c usbpd_hw_if_it.c usbpd_phy_hw_if.c usbpd_pwr_hw_if.c
    ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/src/: usbpd_trace.c
    ../../../../../../../Middlewares/ST/STM32_USBPD_Library/Core/lib/: USBPDCORE_NOPD_CM7_wc32.a
