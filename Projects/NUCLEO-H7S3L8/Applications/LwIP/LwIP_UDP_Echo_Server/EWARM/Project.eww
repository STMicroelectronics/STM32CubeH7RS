<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\LwIP_UDP_Echo_Server_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
