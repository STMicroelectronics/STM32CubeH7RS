<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\LwIP_UDPTCP_Echo_Server_Netconn_RTOS_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
