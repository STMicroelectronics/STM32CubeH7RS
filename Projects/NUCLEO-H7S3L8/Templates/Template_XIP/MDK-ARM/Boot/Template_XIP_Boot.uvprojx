# Keil uVision project Template_XIP_Boot.uvprojx, settings and files
target Template_XIP_Boot (6180000::V6.18::ARMCLANG)
  device: STM32H7S3L8Hx STMicroelectronics
  pack: Keil.STM32H7Rx-7Sx_DFP.0.0.3
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x800FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Boot_XIP +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7S3xx
  c include: ../../Boot/Inc;../../../../../../Drivers/BSP/STM32H7RSxx_Nucleo;../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Middlewares/ST/STM32_ExtMem_manager
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x24000000 size 0x72000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ../: startup_stm32h7s3xx.s
  group Application/User/Boot
    ../../Boot/Src/: main.c extmem_manager.c stm32h7rsxx_it.c stm32h7rsxx_hal_msp.c
  group Doc
    ../../: README.md
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_tim.c stm32h7rsxx_hal_tim_ex.c stm32h7rsxx_hal_xspi.c
  group Drivers/CMSIS
    ../../Boot/Src/: system_stm32h7rsxx.c
  group Middlewares/STM32_ExtMem_manager
    ../../../../../../Middlewares/ST/STM32_ExtMem_manager/: stm32_extmem.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_manager/boot/: stm32_boot_xip.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_manager/sal/: stm32_sal_xspi.c stm32_sal_sd.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_manager/psram/: stm32_psram_driver.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_manager/sdcard/: stm32_sdcard_driver.c
    ../../../../../../Middlewares/ST/STM32_ExtMem_manager/user/: stm32_user_driver.c
software components: CMSIS:CORE 5.6.0
