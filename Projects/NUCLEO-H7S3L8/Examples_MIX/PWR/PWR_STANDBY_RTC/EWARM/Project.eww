<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Boot\PWR_STANDBY_RTC_Boot.ewp</path>
  </project>
  <batchBuild />
</workspace>
