<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\UART_HyperTerminal_TxPolling_RxIT_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
