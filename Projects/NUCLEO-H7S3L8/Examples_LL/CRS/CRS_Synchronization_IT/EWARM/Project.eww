<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Boot\CRS_Synchronization_IT_Boot.ewp</path>
  </project>
  <batchBuild />
</workspace>
