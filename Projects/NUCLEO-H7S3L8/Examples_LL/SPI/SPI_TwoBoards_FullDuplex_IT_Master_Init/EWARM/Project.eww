<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Boot\SPI_TwoBoards_FullDuplex_IT_Master_Init_Boot.ewp</path>
  </project>
  <batchBuild />
</workspace>
