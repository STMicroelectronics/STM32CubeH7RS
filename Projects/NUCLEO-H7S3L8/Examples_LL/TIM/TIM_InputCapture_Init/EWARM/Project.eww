<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Boot\TIM_InputCapture_Init_Boot.ewp</path>
  </project>
  <batchBuild />
</workspace>
