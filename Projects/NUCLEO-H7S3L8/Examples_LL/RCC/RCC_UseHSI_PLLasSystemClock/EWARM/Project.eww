<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Boot\RCC_UseHSI_PLLasSystemClock_Boot.ewp</path>
  </project>
  <batchBuild />
</workspace>
