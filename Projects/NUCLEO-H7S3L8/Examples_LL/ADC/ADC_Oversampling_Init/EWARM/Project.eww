<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Boot\ADC_Oversampling_Init_Boot.ewp</path>
  </project>
  <batchBuild />
</workspace>
