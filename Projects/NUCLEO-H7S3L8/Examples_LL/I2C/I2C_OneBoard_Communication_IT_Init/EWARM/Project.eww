<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Boot\I2C_OneBoard_Communication_IT_Init_Boot.ewp</path>
  </project>
  <batchBuild />
</workspace>
