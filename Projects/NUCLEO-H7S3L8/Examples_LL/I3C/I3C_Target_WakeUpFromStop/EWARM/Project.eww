<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Boot\I3C_Target_WakeUpFromStop_Boot.ewp</path>
  </project>
  <batchBuild />
</workspace>
