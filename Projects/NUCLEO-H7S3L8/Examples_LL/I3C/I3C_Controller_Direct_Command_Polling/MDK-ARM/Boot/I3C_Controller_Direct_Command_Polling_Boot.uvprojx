# Keil uVision project I3C_Controller_Direct_Command_Polling_Boot.uvprojx, settings and files
target I3C_Controller_Direct_Command_Polling_Boot (6210000::V6.21::ARMCLANG)
  device: STM32H7S3L8Hx STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: I3C_Controller_Direct_Command_Polling_Boot +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32H7S3xx,USE_FULL_LL_DRIVER,HSE_VALUE=24000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=64000000,LSI_VALUE=32000,VDD_VALUE=3300,__DBG_ITM
  c include: ../../Boot/Inc;../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include;../../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x24000000 size 0x72000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: stm32h7s3xx_flash.sct
  link misc: --diag_suppress L6312,L6314,L6329
  group Application/MDK-ARM
    ../: startup_stm32h7s3xx.s
  group Application/User/Boot
    ../../Boot/Src/: main.c stm32h7rsxx_it.c
    ./: Retarget.c Serial.c
  group Doc
    ../../: README.md
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_ll_gpio.c stm32h7rsxx_ll_exti.c stm32h7rsxx_ll_rcc.c stm32h7rsxx_ll_utils.c stm32h7rsxx_ll_i3c.c stm32h7rsxx_util_i3c.c stm32h7rsxx_ll_dma.c stm32h7rsxx_ll_pwr.c
  group Drivers/CMSIS
    ../../Boot/Src/: system_stm32h7rsxx.c
software components: CMSIS:CORE 5.6.0
