<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Boot\I3C_Controller_Direct_Command_Polling_Boot.ewp</path>
  </project>
  <batchBuild />
</workspace>
