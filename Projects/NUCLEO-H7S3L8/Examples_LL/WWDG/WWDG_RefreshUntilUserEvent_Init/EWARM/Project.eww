<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Boot\WWDG_RefreshUntilUserEvent_Init_Boot.ewp</path>
  </project>
  <batchBuild />
</workspace>
