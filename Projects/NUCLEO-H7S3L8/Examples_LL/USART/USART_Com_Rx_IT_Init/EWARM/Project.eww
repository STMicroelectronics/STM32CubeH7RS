<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Boot\USART_Com_Rx_IT_Init_Boot.ewp</path>
  </project>
  <batchBuild />
</workspace>
