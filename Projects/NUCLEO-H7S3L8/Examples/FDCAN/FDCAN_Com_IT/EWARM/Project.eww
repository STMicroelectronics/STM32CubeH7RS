<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\FDCAN_Com_IT_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
