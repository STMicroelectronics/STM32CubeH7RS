<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\FDCAN_Com_Polling_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
