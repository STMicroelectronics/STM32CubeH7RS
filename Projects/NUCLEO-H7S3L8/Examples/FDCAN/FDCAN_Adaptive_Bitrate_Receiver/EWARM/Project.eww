<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\FDCAN_Adaptive_Bitrate_Receiver_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
