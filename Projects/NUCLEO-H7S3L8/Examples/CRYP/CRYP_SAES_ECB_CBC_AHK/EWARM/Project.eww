<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\CRYP_SAES_ECB_CBC_AHK_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
