<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Boot\FLASH_ECC_Error_Generation_Boot.ewp</path>
  </project>
  <batchBuild />
</workspace>
