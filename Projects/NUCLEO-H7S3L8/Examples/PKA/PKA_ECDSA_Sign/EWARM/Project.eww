<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\PKA_ECDSA_Sign_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
