<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\RCC_CRS_Synchronization_IT_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
