<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\SMBUS_TwoBoards_ComIT_Slave_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
