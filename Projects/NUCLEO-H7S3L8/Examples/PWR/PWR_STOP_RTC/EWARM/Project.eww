<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\PWR_STOP_RTC_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
