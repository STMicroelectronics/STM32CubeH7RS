<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\CRC_Bytes_Stream_7bit_CRC_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
