<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\RTC_ActiveTamper_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
