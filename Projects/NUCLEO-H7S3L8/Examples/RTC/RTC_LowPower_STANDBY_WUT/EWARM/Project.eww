<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\RTC_LowPower_STANDBY_WUT_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
