<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\GPIO_EXTI_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
