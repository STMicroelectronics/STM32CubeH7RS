<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\PSSI_Slave_Com_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
