<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\PSSI_Master_Single_Com_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
