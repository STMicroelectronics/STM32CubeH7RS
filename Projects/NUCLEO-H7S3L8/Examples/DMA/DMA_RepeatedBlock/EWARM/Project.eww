<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\DMA_RepeatedBlock_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
