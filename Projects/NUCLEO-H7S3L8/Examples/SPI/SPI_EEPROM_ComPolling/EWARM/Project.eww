<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\SPI_EEPROM_ComPolling_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
