<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\I3C_Controller_I2C_ComDMA_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
