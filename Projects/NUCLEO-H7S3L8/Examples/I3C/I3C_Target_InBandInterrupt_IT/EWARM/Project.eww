<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\I3C_Target_InBandInterrupt_IT_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
