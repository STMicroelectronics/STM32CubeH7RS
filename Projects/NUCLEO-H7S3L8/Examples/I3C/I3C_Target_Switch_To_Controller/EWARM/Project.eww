<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\I3C_Target_Switch_To_Controller_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
