<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\I2C_TwoBoards_ComDMA_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
