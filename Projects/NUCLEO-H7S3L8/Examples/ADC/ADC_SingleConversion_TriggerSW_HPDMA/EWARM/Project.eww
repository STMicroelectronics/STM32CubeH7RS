<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\ADC_SingleConversion_TriggerSW_HPDMA_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
