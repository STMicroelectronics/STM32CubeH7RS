<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\LPTIM_PWM_LSE_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
