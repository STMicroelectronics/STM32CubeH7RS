<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\TIM_OCToggle_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
