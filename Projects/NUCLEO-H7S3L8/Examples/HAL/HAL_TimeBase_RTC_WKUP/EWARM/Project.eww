<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\HAL_TimeBase_RTC_WKUP_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
