<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Boot\Templates_Board_Boot.ewp</path>
  </project><project>
    <path>$WS_DIR$\Appli\Templates_Board_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
