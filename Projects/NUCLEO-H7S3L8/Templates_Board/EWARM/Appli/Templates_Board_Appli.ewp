# IAR project Templates_Board_Appli.ewp, settings and files
configuration Templates_Board_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S3L8 ST STM32H7S3L8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7S3xx; USE_NUCLEO_64
  ICCARM.CCIncludePath2: ../../Appli/Inc; ../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc; ../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/BSP/STM32H7RSxx_Nucleo; ../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; ../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Templates_Board_Appli.hex
  ILINK.IlinkOutputFile: Templates_Board_Appli.out
  ILINK.IlinkIcfFile: stm32h7rsxx_ROMxspi2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32h7s3xx.s
  group Application/User/Appli
    ../../Appli/Src/: main.c stm32h7rsxx_it.c stm32h7rsxx_hal_msp.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../Appli/Src/: system_stm32h7rsxx.c
  group Drivers/BSP/STM32H7xx_Nucleo
    ../../../../../Drivers/BSP/STM32H7RSxx_Nucleo/: stm32h7rsxx_nucleo.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_tim.c stm32h7rsxx_hal_tim_ex.c stm32h7rsxx_hal_usart.c stm32h7rsxx_hal_usart_ex.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_uart.c
